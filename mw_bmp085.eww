<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mw_bmp085.ewp</path>
  </project>
  <batchBuild/>
</workspace>


